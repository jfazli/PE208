# Keil uVision project Project.uvproj, settings and files
target STM32F429 (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F429X, USE_STDPERIPH_DRIVER,SILICON_CHIP,REV_A,USE_STM32F4, CAP_TOUCH
  c misc: --c99
  c include: ..\inc;..\includeAPIs;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Libraries\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;.
  asm misc: --apcs=/softfp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: fmc_sdram.c fmc_sram.c io_expander.c i2c_common.c usart_1.c stm324x9i_eval_lcd.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval_fmc_sram.c stm324x9i_eval.c stm324x9i_eval_ioe16.c stm324x9i_eval_ioe8.c stm324x9i_eval_fmc_nor.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_ltdc.c stm32f4xx_fmc.c stm32f4xx_dma2d.c
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM4/DeviceSupport/ST/STM32F4xx/startup/: startup_stm32f4xx.s
  group MicroEJ
    ../src/: LLINPUT.c LLLEDS.c LLMJVM_RTX.c LLSP_RTX.c RTX_Conf_CM.c interrupts.c ioe.c main.c microui_bsp.c putchar.c stm32f4xx_it.c time_hardware_timer.c touch.c touch_listener.c LLDISPLAY_STM32x0DISCO.c buttons.c buttons_listener.c ImplementationProtocole.c joystick.c mathworks.c MICRO_Serial.c MICRO_Spi.c MICRO_Timer.c PCOM_Communication.c PCOM_DataLink.c PCOM_Gpio.c PCOM_Spi.c PCOM_Time.c PCOM_Uart.c sensors.c sram_driver.c system_stm32f4xx.c PID.c APPLI_InteractiveCookware.c SNI_nativeInterfaceJVM.c
    ./: ioe_task.c tscaps.c
  group libs
    C:/Users/jfazli/.microej/workspaces/CM_ARMCC-DEV-2.0.0/F429HMIPlatform-jpf/source/MICROJVM/lib/: mjvm.lib
    C:/Users/jfazli/.microej/workspaces/CM_ARMCC-DEV-2.0.0/F429HMIPlatform-jpf/source/lib/: alpha_numeric_display.lib audio.lib display.lib display_decoder_bmpm.lib display_decoder_png.lib input.lib leds.lib sp.lib
    ../../../../F429HMIPlatform-jpf/source/lib/: javaapp.o
